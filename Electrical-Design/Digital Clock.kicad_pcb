# Repository Rt-Trianglr/Digital-Clock

File README.md:

# Digital-Clock
A tiny digital clock with alarm clock and calendar function

English(machine translated)

# Notice
**This project is no longer maintained and is now for learning purposes only**

It was abandoned because this design has many bugs that have not been fixed and many thorny issues have arisen.

The bugs are:
1. LDO related capacitive pads are not designed as tantalum capacitive pads.
2. Switch connected to the MCU has a wrong design.
3. USB is not routed according to the differential distribution method.
4. The power circuit is in a mess.
5. Clock chip prices are too high.

# Wanted to use it?
1. You can choose SDCC for C programs ,the website is https://sdcc.sourceforge.net/
2. The MCU is STC15W201s or STC15W204s ,the docs website is http://stcmcudatazcom/
3. Other websites:
    1. CH340N:https://www.wch.cn/products/CH340.html?from=list
    2. SGM2028:http://cn.sg-micro.com/

## KiCad design Electrical-Design/Digital Clock.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer1230
C1, C5: 104; C_0201_0603Metric
C2: 47uF; C_0603_1608Metric
C3: 0.1uF; C_0201_0603Metric
C4: 1uF; C_0201_0603Metric
CBP1: 0.01uF; C_0201_0603Metric
CIN1: 1uF; C_0201_0603Metric
COUT1: 1uF; C_0201_0603Metric
D1: Digital_tube
J1: USB_B_Micro; USB
R2, R3, R4: 10K; R_0201_0603Metric
R5: 1650R; R_0201_0603Metric
SW1, SW2, SW3, SW5: SW_Push; Switch
U1: CH340N; SOP-8_3.9x4.9mm_P1.27mm
U2: SGM2028; SOT-23-5
U3: DS3231
U4: STC15W207S; STC_SOP-16_3.9x9.9mm_P1.27mm
U5: TM1650

Connections:
/A: D1.5 (A), U5.8 (A/KI1)
/B: D1.6 (B), U5.9 (B/KI2)
/C: D1.7 (C), U5.11 (C/KI3)
/D: D1.8 (D), U5.12 (D/KI4)
/DIG1: D1.1 (DIG1), U5.1 (DIG1)
/DIG2: D1.3 (DIG3), U5.5 (DIG2)
/DIG3: D1.4 (DIG4), U5.6 (DIG3)
/DIG4: D1.2 (DIG2), U5.7 (DIG4)
/DP: D1.12 (H), U5.16 (DP/KP)
/E: D1.9 (E), U5.13 (E/KI5)
/F: D1.10 (F), U5.14 (F/KI6)
/G: D1.11 (G), U5.15 (G/KI7)
/P1.0: R4.1, U3.16 (SCL), U4.15 (P1.0/RSTOUT_LOW)
/P1.1: BZ1.1 (-), R5.2, U4.16 (P1.1)
/P1.2: U4.1 (CMPO/T0/P1.2), U5.2 (SCL)
/P1.3: U4.2 (P1.3), U5.3 (SDA)
/P1.4: SW2.2, U4.3 (T0CLKO/P1.4)
/P1.5: SW3.2, U4.4 (P1.5)
/P3.2: SW1.2, SW2.1, SW3.1, SW5.1, U4.11 (P3.2/INT0)
/P3.3: U3.4 (~RST), U4.12 (P3.3/INT1)
/P3.7: R3.2, U3.15 (SDA), U4.14 (P3.7/~INT3/TXD_2)
/P5.4: SW5.2, U4.5 (CMP-/MCLKO/RST/P5.4)
/P5.5: SW1.1, U4.7 (CMP+/P5.5)
/RX: U1.6 (TXD), U4.9 (P3.0/RxD/~INT4/T2CLKO)
/TX: U1.7 (RXD), U4.10 (P3.1/TXD/T2)
/UD+: J1.3 (D+), U1.1 (UD+)
/UD-: J1.2 (D-), U1.2 (UD-)
/~INT2: R2.2, U3.3 (~INT/SQW), U4.13 (P3.6/~INT2/RXD_2)
GND: BZ1.2 (+), C1.2, C2.1, C3.1, C4.2, C5.2, CBP1.2, CIN1.1, COUT1.1, J1.4 (ID), J1.5 (GND), J1.6 (Shield), U1.3 (GND), U1.4 (RTS#), U2.2 (GND), U3.1 (32kHz), U3.5 (N.C.), U3.6 (N.C.), U3.7 (N.C.), U3.8 (N.C.), U3.9 (N.C.), U3.10 (N.C.), U3.11 (N.C.), U3.12 (N.C.), U3.13 (GND), U3.14 (VBAT), U4.8 (GND), U5.4 (GND)
unnamed: CIN1.2, J1.1 (VBUS), U2.1 (IN), U2.3 (EN)
unnamed: CBP1.1, U2.4 (BP)
VCC: C1.1, C2.2, C3.2, C4.1, C5.1, COUT1.2, R2.1, R3.1, R4.2, R5.1, U1.5 (VCC), U1.8 (V3), U2.5 (OUT), U3.2 (VCC), U4.6 (VCC), U5.10 (VDD)

Notes on the sheet:
MCU
数码管
蜂鸣器
USB转UART

Board: 4 copper layers, 45.4 x 29.5 mm, 26 parts (6 on the bottom side), 32 nets.

Other parts of the board:
G1, G2: LOGO

## Commit log

2024-03-10 Add files to init the repository
    Add LICENSE and README
2024-03-10 Add the project
    Add the project
2024-03-10 Update and rename Digital Clock-job.gbrjob to 1
2024-03-10 Add Gerber Files
